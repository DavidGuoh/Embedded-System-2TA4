# Keil uVision project lab2.uvprojx, settings and files
target lab2 (6190000::V6.19::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab2
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: STM32F429xx,HSE_VALUE=8000000, USE_STM32F429I_DISCO
  c include: .\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./src/: stm32f4xx_it.c main.c stm32f4xx_hal_msp.c Hal_eeprom.c
  group inc
    ./inc/: main.h stm32f4xx_it.h Hal_eeprom.h
software components: CMSIS:CORE 5.6.0, Board Support:Buttons 1.0.0, Board Support:Components:ILI9341 1.0.2, Board Support:Components:STMPE811 2.0.0, Board Support:Drivers:Basic I/O 1.0.0, Board Support:Drivers:I/O 1.0.0, Board Support:Drivers:LCD 1.0.0, Board Support:Drivers:SDRAM 1.0.0, Board Support:LED 1.0.0, Device:STM32Cube Framework:Classic 1.7.13, Device:STM32Cube HAL:Common 1.7.13, Device:STM32Cube HAL:Cortex 1.7.13, Device:STM32Cube HAL:DMA 1.7.13, Device:STM32Cube HAL:DMA2D 1.7.13, Device:STM32Cube HAL:EXTI 1.7.13, Device:STM32Cube HAL:Flash 1.7.13, Device:STM32Cube HAL:GPIO 1.7.13, Device:STM32Cube HAL:I2C 1.7.13, Device:STM32Cube HAL:I2S 1.7.13, Device:STM32Cube HAL:LTDC 1.7.13, Device:STM32Cube HAL:PWR 1.7.13, Device:STM32Cube HAL:RCC 1.7.13, Device:STM32Cube HAL:RNG 1.7.13, Device:STM32Cube HAL:SDRAM 1.7.13, Device:STM32Cube HAL:SPI 1.7.13, Device:STM32Cube HAL:SRAM 1.7.13, Device:STM32Cube HAL:TIM 1.7.13, Device:STM32Cube HAL:UART 1.7.13, Device:Startup 2.6.3
